# Keil uVision project STM32F1xx.uvprojx, settings and files
target Stm32F1xxOtaBoot (6160000::V6.16::ARMCLANG)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F1xx
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER,
  c include: ..\lib\CMSIS;..\lib\CMSIS\include;..\src\main;..\lib\STM32F10x_StdPeriph_Driver\inc;..\src\bsp\inc;..\src\hal\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ../lib/CMSIS/startup/arm/: startup_stm32f10x_md.s
  group STM32F10x_StdPeriph_Driver
    ../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_usart.c
  group Main
    ../src/main/: main.c stm32f10x_it.c system_stm32f10x.c
  group Bsp
    ../src/bsp/src/: bsp_systick.c bsp_flash.c bsp_master_usart.c
  group Hal
    ../src/hal/src/: hal_modem.c
software components: CMSIS:CORE 5.6.0
